File: PCB/YamhillFrontPanel/YamhillFrontPanel.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: Front Panel Rev B revisions
Parts:
- renumbered H3 to H2, H2 to H3
